# Keil uVision project OSP-STEVAL.uvproj, settings and files
target OSP-Reference (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: OspSensorHub
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ANDROID_DEMO,HSE_VALUE=16000000,USE_STDPERIPH_DRIVER,STM32F10X_HD,DEBUG_BUILD,DEBUG_OUTPUT,STEVAL_MKI109V2,UART_DMA_ENABLE,ASF_PROFILING,ON_DEMAND_PROFILING
  c include: ..\..\..\Common\App;..\..\..\Common\ASF;..\Sources\App;..\Sources\Config;..\Sources\BoardSupport;..\..\..\Common\Modules\Sensor-Drivers;..\..\..\Common\Modules\Bus-drivers;..\..\..\..\external\MCU\STM32F1-CM3\CSLib;..\..\..\..\external\MCU\STM32F1-CM3\CSLib\inc;..\..\..\..\external\RTOS\RTX\inc;..\..\..\..\external\MCU\CMSIS\Device\ST\STM32F10x\Include;..\..\..\..\external\RTOS\RTX\CM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../../../../external/MCU/STM32F1-CM3/: startup_stm32f10x_hd.s
  group CSLib
    ../../../../external/MCU/STM32F1-CM3/CSLib/Src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
  group Retarget
    ../../../../external/MCU/STM32F1-CM3/Retarget/: Retarget.c
  group ASF
    ../../../Common/ASF/: ASF_Messages.c ASF_TaskInit.c ASF_Timers.c
  group RTOS
    ../Sources/Config/: RTX_Conf_CM.c
    ../../../../external/RTOS/RTX/lib/: RTX_CM3.lib
  group App-Common
    ../../../Common/App/: Alg_Conversion.c CmdHandler_T.c DebugPrint.c InstrMgr_T.c InstrMgr_User.c SensorAcq_T.c Algorithm_T.c
  group App
    ../Sources/App/: Console_Util.c Main.c TaskInit_User.c SensorDescriptors.c I2C_SlaveComm_T.c
  group BoardSupport
    ../Sources/BoardSupport/: hw_setup.c stm32f10x_it.c system_stm32f10x.c
  group Bus-Drivers
    ../../../Common/Modules/Bus-drivers/STM32F1-CM3/: I2C_Driver.c
  group Sensor-Drivers
    ../../../Common/Modules/Sensor-Drivers/: Acc_LSM303DLHC_I2C.c Gyro_L3GD20_I2C.c Mag_LSM303DLHC_I2C.c
