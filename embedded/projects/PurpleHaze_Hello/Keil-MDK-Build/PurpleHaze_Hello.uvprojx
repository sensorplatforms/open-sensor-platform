# Keil uVision project PurpleHaze_Hello.uvprojx, settings and files
target PurpleHaze-Rev-F (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F091RC STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: PurpleHaze-RevF-Hello
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=12288000,DEBUG_BUILD,USE_STDPERIPH_DRIVER,STM32F091,PURPLE_HAZE_BOARD,UART_DMA_ENABLE,ON_DEMAND_PROFILING,ASF_PROFILING,PH_REV_F, DEBUG_BOARD_PRESENT, I2C_DRIVER_ENABLE
  c include: ..\Sources\App;..\Sources\Config;..\Sources\BoardSupport;..\..\..\..\include;..\..\..\common\app;..\..\..\common\asf;..\..\..\..\external\RTOS\RTX\inc;..\..\..\..\external\RTOS\RTX\CM;..\..\..\..\external\MCU\STM32F0-CM0\CSLib\inc;..\..\..\..\external\MCU\CMSIS\Device\ST\STM32F0xx\Include;..\..\..\common\modules\bus-drivers
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group StartUp
    ../../../../External/MCU/STM32F0-CM0/: startup_stm32f091.s
  group CSLib
    ../../../../external/MCU/STM32F0-CM0/CSLib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Retarget
    ../../../../external/MCU/STM32F0-CM0/Retarget/: Retarget.c
  group ASF
    ../../../common/asf/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../Sources/Config/: rtx_conf_cm.c
    ../../../../External/RTOS/RTX/Lib/: RTX_CM0_Prof_Dbg.lib
  group App-Common
    ../../../common/app/: cmdhandler_t.c debugprint.c instrmgr_t.c
  group App
    ../Sources/App/: Main.c Console_Util.c InstrMgr_User.c TaskInit_User.c DebugIF_T.c
  group BoardSupport
    ../Sources/boardsupport/: hw_setup.c stm32f0xx_it.c system_stm32f0xx.c
  group Bus-Driver
    ../../../Common/Modules/Bus-Drivers/STM32F0xx-CM0/: i2c_driver.c
software components: CMSIS:CORE 4.3.0
