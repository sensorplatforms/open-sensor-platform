# Keil uVision project osp-steval.uvprojx, settings and files
target OSP-Reference (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OspSensorHub
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: ANDROID_DEMO,HSE_VALUE=16000000,USE_STDPERIPH_DRIVER,STM32F10X_HD,DEBUG_BUILD,DEBUG_OUTPUT,STEVAL_MKI109V2,UART_DMA_ENABLE,ASF_PROFILING,ON_DEMAND_PROFILING
  c include: ..\..\..\..\include;..\..\..\common\app;..\..\..\common\asf;..\..\..\common\alg;..\sources\app;..\sources\config;..\sources\boardsupport;..\..\..\common\modules\sensor-drivers;..\..\..\common\modules\bus-drivers;..\..\..\..\external\mcu\stm32f1-cm3\cslib;..\..\..\..\external\mcu\stm32f1-cm3\cslib\inc;..\..\..\..\external\rtos\rtx\inc;..\..\..\..\external\mcu\cmsis\device\st\stm32f10x\include;..\..\..\..\external\rtos\rtx\cm;..\..\..\..\algorithm\osp
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../../../../external/MCU/STM32F1-CM3/: startup_stm32f10x_hd.s
  group Retarget
    ../../../../external/MCU/STM32F1-CM3/Retarget/: Retarget.c
  group ASF
    ../../../common/asf/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../sources/config/: rtx_conf_cm.c
    ../../../../external/RTOS/RTX/lib/: RTX_CM3.lib
  group Alg
    ../../../../algorithm/osp/lib/: osp_algs_CM3.lib
  group App-Common
    ../../../common/app/: cmdhandler_t.c debugprint.c instrmgr_t.c instrmgr_user.c
  group App
    ../sources/app/: algorithm_t.c console_util.c i2c_slavecomm_t.c main.c sensoracq_t.c taskinit_user.c
  group BoardSupport
    ../Sources/BoardSupport/: hw_setup.c stm32f10x_it.c system_stm32f10x.c
  group Bus-Drivers
    ../../../common/modules/bus-drivers/stm32f1-cm3/: i2c_driver.c
  group Sensor-Drivers
    ../../../common/modules/sensor-drivers/: acc_lsm303dlhc_i2c.c gyro_l3gd20_i2c.c mag_lsm303dlhc_i2c.c
software components: CMSIS:CORE 4.3.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
