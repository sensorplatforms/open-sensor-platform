# Keil uVision project SH-Xpresso-LPC54102.uvprojx, settings and files
target LPC54102 [Debug] (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC54101J512BD64:M4 NXP
  pack: Keil.LPC54000_DFP.1.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SH-Xpresso-LPC54102
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: SYSTEM_CLOCK_FREQ=96000000, __FPU_PRESENT=1, CHIP_LPC5410X, CORE_M4, DEBUG_BUILD, XPRESSO_LPC54102_BOARD, UART_DMA_ENABLE, ANDROID_DEMO
  c include: ..\sources\app;..\sources\config;..\sources\boardsupport;..\..\..\..\include;..\..\..\common\app;..\..\..\common\asf;..\..\..\common\alg;..\..\..\..\external\rtos\rtx\inc;..\..\..\..\external\rtos\rtx\cm;..\..\..\..\external\MCU\NXP-5410x\CSLib\inc;..\..\..\common\modules\bus-drivers;..\..\..\common\modules\sensor-drivers;..\..\..\..\external\Drivers\Sensor\Bosch-Sensortec;..\..\..\common\hostinterface
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group StartUp
    ../../../../external/MCU/NXP-5410x/startup/: keil_startup_lpc5410x.s
  group CSLib
    ../../../../external/MCU/NXP-5410x/CSLib/Libs/: lib_chip_5410x.lib keil_lib_power.lib
  group Retarget
    ../../../../external/MCU/NXP-5410x/Retarget/: Retarget.c
  group ASF
    ../../../common/asf/: asf_messages.c asf_taskinit.c asf_timers.c
  group RTOS
    ../sources/config/: rtx_conf_cm.c
    ../../../../external/RTOS/RTX/lib/: RTX_CM4F.lib
  group Alg
    ../../../../algorithm/osp/lib/: osp_algs_CM3.lib
    ../../../fmlib/: FMLib_Embedded.lib
  group App-Common
    ../../../common/app/: cmdhandler_t.c debugprint.c instrmgr_t.c instrmgr_user.c
  group App
    ../sources/app/: algorithm_t.c console_util.c hostif_i2c.c i2c_slavecomm_t.c main.c sensoracq_t.c taskinit_user.c
  group BoardSupport
    ../sources/boardsupport/: hw_setup.c lpc54Xxx_it.c
  group BusDrivers
    ../../../common/modules/bus-drivers/lpc5410x-cm4/: I2C_Driver.c I2CS_Driver.c
    ../sources/boardsupport/: SPI_SlaveDriver.c
    ../../../common/modules/sensor-drivers/: Bosch_I2C_Adapter.c
  group Sensor-Drivers
    ../../../common/modules/sensor-drivers/: acc_bmc150_i2c.c gyro_bmg160_i2c.c mag_bmc150_i2c.c
    ../../../../external/Drivers/Sensor/Bosch-Sensortec/: bma2x2.c BMG160.c bmm050.c
  group HostIF
    ../../../common/hostinterface/: BlockMemory.c Queue.c SensorPackets.c
target LPC54102-MotionQ [Debug] (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC54101J512BD64:M4 NXP
  pack: Keil.LPC54000_DFP.1.1.0
  cpu: as above
  output: SH-Xpresso-LPC54102-MQ
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: as above
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
software components: CMSIS:CORE 4.3.0
