# Keil uVision project osp_algs.uvprojx, settings and files
target osp-algs-CM3 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: osp_algs_CM3 (library)
  AfterMake: cmd /c "copy /Y obj-CM3\osp_algs_CM3.lib ..\lib\"
  c flags: OneElfS=1 uC99=1 wLevel=2
  c include: ..\include;..\..\osp;..\..\..\include;..\..\..\embedded\common\alg
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ../: ecompass.c fp_atan2.c fp_sqrt.c fp_trig.c fpsup.c gravity_lin.c osp.c rotvec.c SecondOrderLPF.c tilt.c
    ../../../embedded/common/alg/: signalgenerator.c significantmotiondetector.c stepdetector.c stepsegmenter.c
